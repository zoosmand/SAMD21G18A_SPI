# Keil uVision project SAMD21G18A_SPI.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAMD21G18A Atmel
  pack: Keil.SAMD21_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SAMD21G18A_SPI
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
